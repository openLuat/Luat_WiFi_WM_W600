# Keil uVision project WM_W600.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: WM_W600 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: makeimg.bat
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=1
  c define: WM_W600
  c misc: --c99 --gnu
  c include: ..\..\..\Include;..\..\..\Src\Network\api;..\..\..\Src\Wlan\Driver;..\..\..\Src\Wlan\Supplicant;..\..\..\Platform\Common\Params;..\..\..\Platform\Common\task;..\..\..\Platform\Common\mem;..\..\..\Platform\Common\fwup;..\..\..\Platform\Common\utils;..\..\..\Platform\Inc;..\..\..\Platform\Sys;..\..\..\Src\App\wm_atcmd;..\..\..\Src\App\demo;..\..\..\Src\App\dhcpserver;..\..\..\Src\App\dnsserver;..\..\..\Src\App\matrixssl;..\..\..\Src\App\matrixssl\crypto;..\..\..\Src\App\libupnp-1.6.19\ixml\inc;..\..\..\Src\App\libupnp-1.6.19\upnp\inc;..\..\..\Src\App\libupnp-1.6.19\ixml\include;..\..\..\Src\App\libupnp-1.6.19\threadutil\include;..\..\..\Src\App\libupnp-1.6.19\upnp\include;..\..\..\Src\App\gmediarender-0.0.6;..\..\..\Src\App\web;..\..\..\Src\App\cloud;..\..\..\Src\App\cJSON;..\..\..\Src\App\ajtcl-15.04.00a\inc;..\..\..\Src\App\ajtcl-15.04.00a\target\winnermicro;..\..\..\Src\App\ajtcl-15.04.00a\external\sha2;..\..\..\Src\App\cJSON;..\..\..\Src\App\cloud\Kii;..\..\..\Src\App\rmms;..\..\..\Demo;..\..\..\Src\App\ntp;..\..\..\Src\OS\OS_ports;..\..\..\Src\App\httpclient;..\..\..\Src\App\oneshotconfig;..\..\..\Lib;..\..\..\Src\App\iperf;..\..\..\Src\OS\uCOS-II;..\..\..\Src\OS\uCOS-II\ports;..\..\..\Src\OS\uCOS-II\source;..\..\..\Src\OS\RTOS\include;..\..\..\Platform\Common\crypto;..\..\..\Include\App;..\..\..\Include\Driver;..\..\..\Include\Net;..\..\..\Include\OS;..\..\..\Include\Platform;..\..\..\Include\WiFi;..\..\..\Src\App\matrixssl\core;..\..\..\Platform\Common\crypto\digest;..\..\..\Platform\Common\crypto\math;..\..\..\Platform\Common\crypto\symmetric;..\..\..\Src\App\mqtt;..\..\..\Src\App\iperf;..\..\..\Src\App\ping;..\..\..\Src\App\polarssl\include;..\..\..\Src\App\mDNS\mDNSPosix;..\..\..\Src\App\mDNS\mDNSCore;..\..\..\Src\Network\lwip2.0.3\include;..\..\..\Src\App\OTA;..\..\..\Src\App\libwebsockets-2.1-stable;..\..\..\Platform\Boot\gcc;..\..\..\Include\AirM2M;..\..\..\include\App
  asm include: ..\..\..\Include\OS
  library: MicroLIB
  memory RVCT4: ROM 0x800e000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group main
    ../../../App/: main.c
  group Platform
    ../../../Platform/Boot/armcc/: startup_venus.s retarget.c misc.c
    ../../../Platform/Sys/: wm_main.c tls_sys.c
    ../../../Platform/Drivers/: wm_driver.c
    ../../../Platform/Common/: wm_common.c
  group demo
    ../../../Demo/: wm_7816_demo.c wm_uart_demo.c wm_gpio_demo.c wm_flash_demo.c wm_pwm_demo.c wm_slave_spi_demo.c wm_master_spi_demo.c wm_rtc_demo.c wm_timer_demo.c wm_pmu_demo.c wm_crypt_hard_demo.c wm_rsa_demo.c wm_socket_client_demo.c wm_connect_net_demo.c wm_http_demo.c wm_adc_demo.c wm_apsta_demo.c wm_softap_demo.c wm_ntp_demo.c wm_udp_demo.c wm_socket_server_demo.c wm_mcast_demo.c wm_wps_demo.c wm_iperf_auto_demo.c wm_ssl_server_demo.c wm_websockets_demo.c
    ../../../Demo/console/: wm_demo_console_task.c
  group DhcpServer
    ../../../Src/App/dhcpserver/: dhcp_server.c
  group DnsServer
    ../../../Src/App/dnsserver/: dns_server.c
  group oneshotcfg
    ../../../Src/App/oneshotconfig/: wm_wifi_oneshot.c wm_oneshot_airkiss.c libairkiss_log.lib
  group Cmd
    ../../../Src/App/wm_atcmd/: wm_cmd.c
  group OS
    ../../../Src/OS/RTOS/: wm_rtos.c
  group LWIP
    ../../../Src/Network/: lwip2.0.3.c lwip.c
  group NTP
    ../../../Src/App/ntp/: ntp_client.c
  group websocket
    ../../../Src/App/libwebsockets-2.1-stable/: base64-decode.c client.c client-handshake.c client-parser.c context.c handshake.c header.c libwebsockets.c lws-plat-wm.c output.c parsers.c pollfd.c service.c ssl.c ssl-client.c
  group libcoap
    ../../../Src/App/libcoap/: address.c async.c block.c coap_time.c debug.c encode.c hashkey.c option.c pdu.c resource.c str.c subscribe.c uri_libcoap.c mem_libcoap.c coap_io_lwip.c net.c
  group cJSON
    ../../../Src/App/cJSON/: cJSON.c
  group HttpClient
    ../../../Src/App/httpclient/: wm_http_compile.c
  group PING
    ../../../Src/App/ping/: ping.c
  group MatrixSSL
    ../../../Src/App/matrixssl/: wm_matrixssl_compile.c
  group Iperf
    ../../../Src/App/iperf/: iperf_api.c iperf_client_api.c iperf_error.c iperf_locale.c iperf_main.c iperf_net.c iperf_server_api.c iperf_tcp.c iperf_timer.c iperf_udp.c iperf_units.c iperf_util.c tcp_info.c tcp_window_size.c wm_perf.c
  group polarssl
    ../../../Src/App/polarssl/library/: asn1parse.c base64.c cipher.c cipher_wrap.c error.c md.c md_wrap.c pem.c rsa.c ssl_cli.c ssl_tls.c x509parse.c polarssl_bignum.c polarssl_debug.c polarssl_md5.c polarssl_sha1.c arc4.c
  group mDNS
    ../../../Src/App/mDNS/mDNSPosix/: mDNSPosix.c
    ../../../Src/App/mDNS/mDNSCore/: mDNS.c
  group wlan_lib
    ../../../Lib/Wlan/: wlan.lib
  group OTA
    ../../../Src/App/OTA/: wm_http_fwup.c wm_socket_fwup.c
  group SSLServer
    ../../../Src/App/sslserver/: wm_ssl_server.c
  group AirM2M_LIB
    ../../../Lib/AirM2M/: airm2m_mqtt.lib airm2m_flash.lib
